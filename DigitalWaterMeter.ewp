# IAR project DigitalWaterMeter.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F415 MSP430F415
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F413.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.CCDefines: NDEBUG
  ICC430.CCDiagSuppress: Pa050
  ICC430.CCOptLevel: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F415.xcl
  group (top)
    SRC/: drive.c drive.h flash.c flash.h global.h intsvc.c intsvc.h iodefine.h lcd.c lcd.h main.c main.h msp430x41x.h
